# systemdサービスを有効化
SYSTEMD_SERVICE_${PN} = "dockerd.service"
SYSTEMD_AUTO_ENABLE = "enable"